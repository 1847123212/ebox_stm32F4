# Keil uVision project First.uvprojx, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: First
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,HSE_VALUE = 8000000
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Driver;..\fat_fs;..\ebox
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Libraries
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ebox
    ../ebox/: ebox_core.cpp ebox_gpio.cpp ebox_uart.cpp ebox_it.cpp ebox_object.cpp ebox_spi.cpp ebox_soft_spi.cpp ebox_soft_iic.cpp ebox_i2c.cpp ebox_gtime.cpp ebox_pwm.cpp ebox_iflash.cpp ebox_adc.cpp ebox_dac.cpp
  group Driver
    ../Driver/: led.c fsmc_sram.c usart.c
  group edriver
    ../edriver/: Button.cpp dht11.cpp 74HC595.cpp
  group User
    ../User/: stm32f4xx_it.c Function.c Init.c main.cpp
software components: CMSIS:CORE 4.1.0
